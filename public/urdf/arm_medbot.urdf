Commit message: new update

File: public/urdf/arm_medbot.urdf (robot description, URDF)
Before this commit: robot piper, 10 links, 9 joints
Joints:
- joint joint8: mimic (none) -> joint=joint7 multiplier=-1.0 offset=0.0
